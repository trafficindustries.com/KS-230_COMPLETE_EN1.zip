Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-09-23T13:45:21
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcBuildingElementProxy: Concrete envelope (4)
In: GRP snow fence
PredefinedType: USERDEFINED
Pset_TI_Product - Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyDescription: Engineering Manufacturing Industry and Trade.; CompanyPhone: +90 532 711 2185; CompanyEmail: info@trafficindustries.com; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; PostalCode: 06105; City: Ankara; Country: Turkiye; ProductName: GRP snow fence; ProductGroup: GRP snow fences; DrawingLanguage: English; LengthUnit: mm; PanelColour: white; PostSpacingCentreToCentre_mm: 2000; RailWidth_mm: 25; RailThickness_mm: 5; RailMaterial: Hot-dip galvanized steel flat bar; PanelMaterial: Overlapping vertical GRP slats in PVC-coated galvanized diamond wire mesh; SlatProfileDesignation: 55 x 8 x 3; SlatFlatWidth_mm: 55; SlatOverallWidth_mm: 65.8; SlatLeftHorizontalProjection_mm: 6; SlatRightHorizontalProjection_mm: 4.8; SlatThickness_mm: 3; SlatEdgeAngle_deg: 135; PanelCapMaterial: GRP; PanelCapColour: white; PanelCapOuterWidth_mm: 26; PanelCapInnerWidth_mm: 20; PanelCapDepth_mm: 60; PanelCapWallThickness_mm: 3; PanelCapTieWireMinimumDiameter_mm: 1.5; PostTopCapMaterial: PVC; PostTopCapColour: white; BraceAngleToPost_deg: 45; EndPostOpposedBraceCount: 2; BraceEmbeddedLengthRange_mm: [350, 500]; FoundationConcreteSpecification: C30/37, reinforced; SteelFinish: Hot-dip galvanized; GalvanizingStandardReference: TS EN ISO 1461; GalvanizingSpecifiedCoatingMass_g_m2: 488; ProductCode: KS-230; PostSectionOuterWidth_mm: 70; PostSectionOuterDepth_mm: 70; PostWallThickness_mm: 3; RailCount: 5; FoundationPlanSideA_mm: 700; FoundationPlanSideB_mm: 500; FoundationDepth_mm: 500; BraceEveryBays: 3; BraceSectionOuterWidth_mm: 70; BraceSectionOuterDepth_mm: 70; BraceWallThickness_mm: 3; PanelHeight_mm: 2300; PanelBottomGL_mm: 50; PanelTopGL_mm: 2350; PostTopGL_mm: 2400; RailCentreHeights_mm: [350, 775, 1200, 1625, 2050]; RailCentreHeightsAbovePanelBase_mm: [300, 725, 1150, 1575, 2000]; BraceConnectionGL_mm: 1775; Revision: R2 / T-002; SlatPitch_mm: 62.5; SlatsPerBay: 31; SlatCutLength_mm: 2294; SlatEndTrimEachSide_mm: 5.4; PostSteelTopGL_mm: 2397; PostEmbedment_mm: 350; ProposalFields: ["BraceAxialEmbedment_mm", "BraceConnectionGL_mm", "BraceSide", "PostCapPlugDepth_mm", "PostCapPlugWall_mm", "PostCapTopThickness_mm", "PostEmbedment_mm", "PostSteelTopGL_mm", "PostTopGL_mm", "RailCentreHeightsAbovePanelBase_mm", "RailCentreHeights_mm", "RailEndClearance_mm", "SlatCutLength_mm", "SlatEndTrimEachSide_mm", "SlatInsideBendRadius_mm", "SlatOverlap_mm", "SlatPitch_mm", "SlatTipRadius_mm", "VerticalChain_mm", "WireDiameter_mm", "WireDiamondDiagonal_mm"]; DrawingNumber: TI-KS230-GA-01; DesignScope: PROPOSED - NOT FOR FABRICATION; CoordinateSystem: X along fence, Y leeward, Z up; ground Z=0; local millimetres; RailEndClearance_mm: 287.5; VerticalChain_mm: [287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5]; ParameterSHA256: d376449958e1f61d950e3d67d0b825ea64825ac4cee81a2d2015eca5addb28ff; SlatOverlap_mm: 3.3; WireDiamondDiagonal_mm: 100; WireDiameter_mm: 2; BraceAxialEmbedment_mm: 350; SlatInsideBendRadius_mm: 1.8799; SlatTipRadius_mm: 1.5; PostCapTopThickness_mm: 3; PostCapPlugDepth_mm: 12; PostCapPlugWall_mm: 2; BraceSide: Leeward *; ProposalLabels: {"BraceAxialEmbedment_mm": "350 *", "BraceConnectionGL_mm": "1775 *", "PostCapPlugDepth_mm": "12 *", "PostCapPlugWall_mm": "2 *", "PostCapTopThickness_mm": "3 *", "PostEmbedment_mm": "350 *", "PostSteelTopGL_mm": "2397 *", "PostTopGL_mm": "2400 *", "RailCentreHeightsAbovePanelBase_mm": "[300, 725, 1150, 1575, 2000] *", "RailCentreHeights_mm": "[350, 775, 1200, 1625, 2050] *", "RailEndClearance_mm": "287.5 *", "SlatCutLength_mm": "2294 *", "SlatEndTrimEachSide_mm": "5.4 *", "SlatInsideBendRadius_mm": "1.879898987322333 *", "SlatOverlap_mm": "3.3 *", "SlatPitch_mm": "62.5 *", "SlatTipRadius_mm": "1.5 *", "VerticalChain_mm": "[287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5] *", "WireDiameter_mm": "2 *", "WireDiamondDiagonal_mm": "100 *"}; ReviewScope: PROPOSED - NOT FOR FABRICATION
Name
foundation_0
foundation_1
foundation_2
brace_foundation

# IfcBuildingElementProxy: Galvanized steel (14)
In: GRP snow fence
PredefinedType: USERDEFINED
Pset_TI_Product - Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyDescription: Engineering Manufacturing Industry and Trade.; CompanyPhone: +90 532 711 2185; CompanyEmail: info@trafficindustries.com; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; PostalCode: 06105; City: Ankara; Country: Turkiye; ProductName: GRP snow fence; ProductGroup: GRP snow fences; DrawingLanguage: English; LengthUnit: mm; PanelColour: white; PostSpacingCentreToCentre_mm: 2000; RailWidth_mm: 25; RailThickness_mm: 5; RailMaterial: Hot-dip galvanized steel flat bar; PanelMaterial: Overlapping vertical GRP slats in PVC-coated galvanized diamond wire mesh; SlatProfileDesignation: 55 x 8 x 3; SlatFlatWidth_mm: 55; SlatOverallWidth_mm: 65.8; SlatLeftHorizontalProjection_mm: 6; SlatRightHorizontalProjection_mm: 4.8; SlatThickness_mm: 3; SlatEdgeAngle_deg: 135; PanelCapMaterial: GRP; PanelCapColour: white; PanelCapOuterWidth_mm: 26; PanelCapInnerWidth_mm: 20; PanelCapDepth_mm: 60; PanelCapWallThickness_mm: 3; PanelCapTieWireMinimumDiameter_mm: 1.5; PostTopCapMaterial: PVC; PostTopCapColour: white; BraceAngleToPost_deg: 45; EndPostOpposedBraceCount: 2; BraceEmbeddedLengthRange_mm: [350, 500]; FoundationConcreteSpecification: C30/37, reinforced; SteelFinish: Hot-dip galvanized; GalvanizingStandardReference: TS EN ISO 1461; GalvanizingSpecifiedCoatingMass_g_m2: 488; ProductCode: KS-230; PostSectionOuterWidth_mm: 70; PostSectionOuterDepth_mm: 70; PostWallThickness_mm: 3; RailCount: 5; FoundationPlanSideA_mm: 700; FoundationPlanSideB_mm: 500; FoundationDepth_mm: 500; BraceEveryBays: 3; BraceSectionOuterWidth_mm: 70; BraceSectionOuterDepth_mm: 70; BraceWallThickness_mm: 3; PanelHeight_mm: 2300; PanelBottomGL_mm: 50; PanelTopGL_mm: 2350; PostTopGL_mm: 2400; RailCentreHeights_mm: [350, 775, 1200, 1625, 2050]; RailCentreHeightsAbovePanelBase_mm: [300, 725, 1150, 1575, 2000]; BraceConnectionGL_mm: 1775; Revision: R2 / T-002; SlatPitch_mm: 62.5; SlatsPerBay: 31; SlatCutLength_mm: 2294; SlatEndTrimEachSide_mm: 5.4; PostSteelTopGL_mm: 2397; PostEmbedment_mm: 350; ProposalFields: ["BraceAxialEmbedment_mm", "BraceConnectionGL_mm", "BraceSide", "PostCapPlugDepth_mm", "PostCapPlugWall_mm", "PostCapTopThickness_mm", "PostEmbedment_mm", "PostSteelTopGL_mm", "PostTopGL_mm", "RailCentreHeightsAbovePanelBase_mm", "RailCentreHeights_mm", "RailEndClearance_mm", "SlatCutLength_mm", "SlatEndTrimEachSide_mm", "SlatInsideBendRadius_mm", "SlatOverlap_mm", "SlatPitch_mm", "SlatTipRadius_mm", "VerticalChain_mm", "WireDiameter_mm", "WireDiamondDiagonal_mm"]; DrawingNumber: TI-KS230-GA-01; DesignScope: PROPOSED - NOT FOR FABRICATION; CoordinateSystem: X along fence, Y leeward, Z up; ground Z=0; local millimetres; RailEndClearance_mm: 287.5; VerticalChain_mm: [287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5]; ParameterSHA256: d376449958e1f61d950e3d67d0b825ea64825ac4cee81a2d2015eca5addb28ff; SlatOverlap_mm: 3.3; WireDiamondDiagonal_mm: 100; WireDiameter_mm: 2; BraceAxialEmbedment_mm: 350; SlatInsideBendRadius_mm: 1.8799; SlatTipRadius_mm: 1.5; PostCapTopThickness_mm: 3; PostCapPlugDepth_mm: 12; PostCapPlugWall_mm: 2; BraceSide: Leeward *; ProposalLabels: {"BraceAxialEmbedment_mm": "350 *", "BraceConnectionGL_mm": "1775 *", "PostCapPlugDepth_mm": "12 *", "PostCapPlugWall_mm": "2 *", "PostCapTopThickness_mm": "3 *", "PostEmbedment_mm": "350 *", "PostSteelTopGL_mm": "2397 *", "PostTopGL_mm": "2400 *", "RailCentreHeightsAbovePanelBase_mm": "[300, 725, 1150, 1575, 2000] *", "RailCentreHeights_mm": "[350, 775, 1200, 1625, 2050] *", "RailEndClearance_mm": "287.5 *", "SlatCutLength_mm": "2294 *", "SlatEndTrimEachSide_mm": "5.4 *", "SlatInsideBendRadius_mm": "1.879898987322333 *", "SlatOverlap_mm": "3.3 *", "SlatPitch_mm": "62.5 *", "SlatTipRadius_mm": "1.5 *", "VerticalChain_mm": "[287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5] *", "WireDiameter_mm": "2 *", "WireDiamondDiagonal_mm": "100 *"}; ReviewScope: PROPOSED - NOT FOR FABRICATION
Name
post_0
post_1
post_2
rail_0_0
rail_0_1
rail_0_2
rail_0_3
rail_0_4
rail_1_0
rail_1_1
rail_1_2
rail_1_3
rail_1_4
brace

# IfcBuildingElementProxy: PVC-coated galvanized wire (4)
In: GRP snow fence
PredefinedType: USERDEFINED
Pset_TI_Product - Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyDescription: Engineering Manufacturing Industry and Trade.; CompanyPhone: +90 532 711 2185; CompanyEmail: info@trafficindustries.com; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; PostalCode: 06105; City: Ankara; Country: Turkiye; ProductName: GRP snow fence; ProductGroup: GRP snow fences; DrawingLanguage: English; LengthUnit: mm; PanelColour: white; PostSpacingCentreToCentre_mm: 2000; RailWidth_mm: 25; RailThickness_mm: 5; RailMaterial: Hot-dip galvanized steel flat bar; PanelMaterial: Overlapping vertical GRP slats in PVC-coated galvanized diamond wire mesh; SlatProfileDesignation: 55 x 8 x 3; SlatFlatWidth_mm: 55; SlatOverallWidth_mm: 65.8; SlatLeftHorizontalProjection_mm: 6; SlatRightHorizontalProjection_mm: 4.8; SlatThickness_mm: 3; SlatEdgeAngle_deg: 135; PanelCapMaterial: GRP; PanelCapColour: white; PanelCapOuterWidth_mm: 26; PanelCapInnerWidth_mm: 20; PanelCapDepth_mm: 60; PanelCapWallThickness_mm: 3; PanelCapTieWireMinimumDiameter_mm: 1.5; PostTopCapMaterial: PVC; PostTopCapColour: white; BraceAngleToPost_deg: 45; EndPostOpposedBraceCount: 2; BraceEmbeddedLengthRange_mm: [350, 500]; FoundationConcreteSpecification: C30/37, reinforced; SteelFinish: Hot-dip galvanized; GalvanizingStandardReference: TS EN ISO 1461; GalvanizingSpecifiedCoatingMass_g_m2: 488; ProductCode: KS-230; PostSectionOuterWidth_mm: 70; PostSectionOuterDepth_mm: 70; PostWallThickness_mm: 3; RailCount: 5; FoundationPlanSideA_mm: 700; FoundationPlanSideB_mm: 500; FoundationDepth_mm: 500; BraceEveryBays: 3; BraceSectionOuterWidth_mm: 70; BraceSectionOuterDepth_mm: 70; BraceWallThickness_mm: 3; PanelHeight_mm: 2300; PanelBottomGL_mm: 50; PanelTopGL_mm: 2350; PostTopGL_mm: 2400; RailCentreHeights_mm: [350, 775, 1200, 1625, 2050]; RailCentreHeightsAbovePanelBase_mm: [300, 725, 1150, 1575, 2000]; BraceConnectionGL_mm: 1775; Revision: R2 / T-002; SlatPitch_mm: 62.5; SlatsPerBay: 31; SlatCutLength_mm: 2294; SlatEndTrimEachSide_mm: 5.4; PostSteelTopGL_mm: 2397; PostEmbedment_mm: 350; ProposalFields: ["BraceAxialEmbedment_mm", "BraceConnectionGL_mm", "BraceSide", "PostCapPlugDepth_mm", "PostCapPlugWall_mm", "PostCapTopThickness_mm", "PostEmbedment_mm", "PostSteelTopGL_mm", "PostTopGL_mm", "RailCentreHeightsAbovePanelBase_mm", "RailCentreHeights_mm", "RailEndClearance_mm", "SlatCutLength_mm", "SlatEndTrimEachSide_mm", "SlatInsideBendRadius_mm", "SlatOverlap_mm", "SlatPitch_mm", "SlatTipRadius_mm", "VerticalChain_mm", "WireDiameter_mm", "WireDiamondDiagonal_mm"]; DrawingNumber: TI-KS230-GA-01; DesignScope: PROPOSED - NOT FOR FABRICATION; CoordinateSystem: X along fence, Y leeward, Z up; ground Z=0; local millimetres; RailEndClearance_mm: 287.5; VerticalChain_mm: [287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5]; ParameterSHA256: d376449958e1f61d950e3d67d0b825ea64825ac4cee81a2d2015eca5addb28ff; SlatOverlap_mm: 3.3; WireDiamondDiagonal_mm: 100; WireDiameter_mm: 2; BraceAxialEmbedment_mm: 350; SlatInsideBendRadius_mm: 1.8799; SlatTipRadius_mm: 1.5; PostCapTopThickness_mm: 3; PostCapPlugDepth_mm: 12; PostCapPlugWall_mm: 2; BraceSide: Leeward *; ProposalLabels: {"BraceAxialEmbedment_mm": "350 *", "BraceConnectionGL_mm": "1775 *", "PostCapPlugDepth_mm": "12 *", "PostCapPlugWall_mm": "2 *", "PostCapTopThickness_mm": "3 *", "PostEmbedment_mm": "350 *", "PostSteelTopGL_mm": "2397 *", "PostTopGL_mm": "2400 *", "RailCentreHeightsAbovePanelBase_mm": "[300, 725, 1150, 1575, 2000] *", "RailCentreHeights_mm": "[350, 775, 1200, 1625, 2050] *", "RailEndClearance_mm": "287.5 *", "SlatCutLength_mm": "2294 *", "SlatEndTrimEachSide_mm": "5.4 *", "SlatInsideBendRadius_mm": "1.879898987322333 *", "SlatOverlap_mm": "3.3 *", "SlatPitch_mm": "62.5 *", "SlatTipRadius_mm": "1.5 *", "VerticalChain_mm": "[287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5] *", "WireDiameter_mm": "2 *", "WireDiamondDiagonal_mm": "100 *"}; ReviewScope: PROPOSED - NOT FOR FABRICATION
Name
wire_mesh_0_0
wire_mesh_0_1
wire_mesh_1_0
wire_mesh_1_1

# IfcBuildingElementProxy: White GRP (66)
In: GRP snow fence
PredefinedType: USERDEFINED
Pset_TI_Product - Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyDescription: Engineering Manufacturing Industry and Trade.; CompanyPhone: +90 532 711 2185; CompanyEmail: info@trafficindustries.com; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; PostalCode: 06105; City: Ankara; Country: Turkiye; ProductName: GRP snow fence; ProductGroup: GRP snow fences; DrawingLanguage: English; LengthUnit: mm; PanelColour: white; PostSpacingCentreToCentre_mm: 2000; RailWidth_mm: 25; RailThickness_mm: 5; RailMaterial: Hot-dip galvanized steel flat bar; PanelMaterial: Overlapping vertical GRP slats in PVC-coated galvanized diamond wire mesh; SlatProfileDesignation: 55 x 8 x 3; SlatFlatWidth_mm: 55; SlatOverallWidth_mm: 65.8; SlatLeftHorizontalProjection_mm: 6; SlatRightHorizontalProjection_mm: 4.8; SlatThickness_mm: 3; SlatEdgeAngle_deg: 135; PanelCapMaterial: GRP; PanelCapColour: white; PanelCapOuterWidth_mm: 26; PanelCapInnerWidth_mm: 20; PanelCapDepth_mm: 60; PanelCapWallThickness_mm: 3; PanelCapTieWireMinimumDiameter_mm: 1.5; PostTopCapMaterial: PVC; PostTopCapColour: white; BraceAngleToPost_deg: 45; EndPostOpposedBraceCount: 2; BraceEmbeddedLengthRange_mm: [350, 500]; FoundationConcreteSpecification: C30/37, reinforced; SteelFinish: Hot-dip galvanized; GalvanizingStandardReference: TS EN ISO 1461; GalvanizingSpecifiedCoatingMass_g_m2: 488; ProductCode: KS-230; PostSectionOuterWidth_mm: 70; PostSectionOuterDepth_mm: 70; PostWallThickness_mm: 3; RailCount: 5; FoundationPlanSideA_mm: 700; FoundationPlanSideB_mm: 500; FoundationDepth_mm: 500; BraceEveryBays: 3; BraceSectionOuterWidth_mm: 70; BraceSectionOuterDepth_mm: 70; BraceWallThickness_mm: 3; PanelHeight_mm: 2300; PanelBottomGL_mm: 50; PanelTopGL_mm: 2350; PostTopGL_mm: 2400; RailCentreHeights_mm: [350, 775, 1200, 1625, 2050]; RailCentreHeightsAbovePanelBase_mm: [300, 725, 1150, 1575, 2000]; BraceConnectionGL_mm: 1775; Revision: R2 / T-002; SlatPitch_mm: 62.5; SlatsPerBay: 31; SlatCutLength_mm: 2294; SlatEndTrimEachSide_mm: 5.4; PostSteelTopGL_mm: 2397; PostEmbedment_mm: 350; ProposalFields: ["BraceAxialEmbedment_mm", "BraceConnectionGL_mm", "BraceSide", "PostCapPlugDepth_mm", "PostCapPlugWall_mm", "PostCapTopThickness_mm", "PostEmbedment_mm", "PostSteelTopGL_mm", "PostTopGL_mm", "RailCentreHeightsAbovePanelBase_mm", "RailCentreHeights_mm", "RailEndClearance_mm", "SlatCutLength_mm", "SlatEndTrimEachSide_mm", "SlatInsideBendRadius_mm", "SlatOverlap_mm", "SlatPitch_mm", "SlatTipRadius_mm", "VerticalChain_mm", "WireDiameter_mm", "WireDiamondDiagonal_mm"]; DrawingNumber: TI-KS230-GA-01; DesignScope: PROPOSED - NOT FOR FABRICATION; CoordinateSystem: X along fence, Y leeward, Z up; ground Z=0; local millimetres; RailEndClearance_mm: 287.5; VerticalChain_mm: [287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5]; ParameterSHA256: d376449958e1f61d950e3d67d0b825ea64825ac4cee81a2d2015eca5addb28ff; SlatOverlap_mm: 3.3; WireDiamondDiagonal_mm: 100; WireDiameter_mm: 2; BraceAxialEmbedment_mm: 350; SlatInsideBendRadius_mm: 1.8799; SlatTipRadius_mm: 1.5; PostCapTopThickness_mm: 3; PostCapPlugDepth_mm: 12; PostCapPlugWall_mm: 2; BraceSide: Leeward *; ProposalLabels: {"BraceAxialEmbedment_mm": "350 *", "BraceConnectionGL_mm": "1775 *", "PostCapPlugDepth_mm": "12 *", "PostCapPlugWall_mm": "2 *", "PostCapTopThickness_mm": "3 *", "PostEmbedment_mm": "350 *", "PostSteelTopGL_mm": "2397 *", "PostTopGL_mm": "2400 *", "RailCentreHeightsAbovePanelBase_mm": "[300, 725, 1150, 1575, 2000] *", "RailCentreHeights_mm": "[350, 775, 1200, 1625, 2050] *", "RailEndClearance_mm": "287.5 *", "SlatCutLength_mm": "2294 *", "SlatEndTrimEachSide_mm": "5.4 *", "SlatInsideBendRadius_mm": "1.879898987322333 *", "SlatOverlap_mm": "3.3 *", "SlatPitch_mm": "62.5 *", "SlatTipRadius_mm": "1.5 *", "VerticalChain_mm": "[287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5] *", "WireDiameter_mm": "2 *", "WireDiamondDiagonal_mm": "100 *"}; ReviewScope: PROPOSED - NOT FOR FABRICATION
Name
slat_0_00
slat_0_01
slat_0_02
slat_0_03
slat_0_04
slat_0_05
slat_0_06
slat_0_07
slat_0_08
slat_0_09
slat_0_10
slat_0_11
slat_0_12
slat_0_13
slat_0_14
slat_0_15
slat_0_16
slat_0_17
slat_0_18
slat_0_19
slat_0_20
slat_0_21
slat_0_22
slat_0_23
slat_0_24
slat_0_25
slat_0_26
slat_0_27
slat_0_28
slat_0_29
slat_0_30
panel_cap_0_bottom
panel_cap_0_top
slat_1_00
slat_1_01
slat_1_02
slat_1_03
slat_1_04
slat_1_05
slat_1_06
slat_1_07
slat_1_08
slat_1_09
slat_1_10
slat_1_11
slat_1_12
slat_1_13
slat_1_14
slat_1_15
slat_1_16
slat_1_17
slat_1_18
slat_1_19
slat_1_20
slat_1_21
slat_1_22
slat_1_23
slat_1_24
slat_1_25
slat_1_26
slat_1_27
slat_1_28
slat_1_29
slat_1_30
panel_cap_1_bottom
panel_cap_1_top

# IfcBuildingElementProxy: White PVC (3)
In: GRP snow fence
PredefinedType: USERDEFINED
Pset_TI_Product - Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyDescription: Engineering Manufacturing Industry and Trade.; CompanyPhone: +90 532 711 2185; CompanyEmail: info@trafficindustries.com; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; PostalCode: 06105; City: Ankara; Country: Turkiye; ProductName: GRP snow fence; ProductGroup: GRP snow fences; DrawingLanguage: English; LengthUnit: mm; PanelColour: white; PostSpacingCentreToCentre_mm: 2000; RailWidth_mm: 25; RailThickness_mm: 5; RailMaterial: Hot-dip galvanized steel flat bar; PanelMaterial: Overlapping vertical GRP slats in PVC-coated galvanized diamond wire mesh; SlatProfileDesignation: 55 x 8 x 3; SlatFlatWidth_mm: 55; SlatOverallWidth_mm: 65.8; SlatLeftHorizontalProjection_mm: 6; SlatRightHorizontalProjection_mm: 4.8; SlatThickness_mm: 3; SlatEdgeAngle_deg: 135; PanelCapMaterial: GRP; PanelCapColour: white; PanelCapOuterWidth_mm: 26; PanelCapInnerWidth_mm: 20; PanelCapDepth_mm: 60; PanelCapWallThickness_mm: 3; PanelCapTieWireMinimumDiameter_mm: 1.5; PostTopCapMaterial: PVC; PostTopCapColour: white; BraceAngleToPost_deg: 45; EndPostOpposedBraceCount: 2; BraceEmbeddedLengthRange_mm: [350, 500]; FoundationConcreteSpecification: C30/37, reinforced; SteelFinish: Hot-dip galvanized; GalvanizingStandardReference: TS EN ISO 1461; GalvanizingSpecifiedCoatingMass_g_m2: 488; ProductCode: KS-230; PostSectionOuterWidth_mm: 70; PostSectionOuterDepth_mm: 70; PostWallThickness_mm: 3; RailCount: 5; FoundationPlanSideA_mm: 700; FoundationPlanSideB_mm: 500; FoundationDepth_mm: 500; BraceEveryBays: 3; BraceSectionOuterWidth_mm: 70; BraceSectionOuterDepth_mm: 70; BraceWallThickness_mm: 3; PanelHeight_mm: 2300; PanelBottomGL_mm: 50; PanelTopGL_mm: 2350; PostTopGL_mm: 2400; RailCentreHeights_mm: [350, 775, 1200, 1625, 2050]; RailCentreHeightsAbovePanelBase_mm: [300, 725, 1150, 1575, 2000]; BraceConnectionGL_mm: 1775; Revision: R2 / T-002; SlatPitch_mm: 62.5; SlatsPerBay: 31; SlatCutLength_mm: 2294; SlatEndTrimEachSide_mm: 5.4; PostSteelTopGL_mm: 2397; PostEmbedment_mm: 350; ProposalFields: ["BraceAxialEmbedment_mm", "BraceConnectionGL_mm", "BraceSide", "PostCapPlugDepth_mm", "PostCapPlugWall_mm", "PostCapTopThickness_mm", "PostEmbedment_mm", "PostSteelTopGL_mm", "PostTopGL_mm", "RailCentreHeightsAbovePanelBase_mm", "RailCentreHeights_mm", "RailEndClearance_mm", "SlatCutLength_mm", "SlatEndTrimEachSide_mm", "SlatInsideBendRadius_mm", "SlatOverlap_mm", "SlatPitch_mm", "SlatTipRadius_mm", "VerticalChain_mm", "WireDiameter_mm", "WireDiamondDiagonal_mm"]; DrawingNumber: TI-KS230-GA-01; DesignScope: PROPOSED - NOT FOR FABRICATION; CoordinateSystem: X along fence, Y leeward, Z up; ground Z=0; local millimetres; RailEndClearance_mm: 287.5; VerticalChain_mm: [287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5]; ParameterSHA256: d376449958e1f61d950e3d67d0b825ea64825ac4cee81a2d2015eca5addb28ff; SlatOverlap_mm: 3.3; WireDiamondDiagonal_mm: 100; WireDiameter_mm: 2; BraceAxialEmbedment_mm: 350; SlatInsideBendRadius_mm: 1.8799; SlatTipRadius_mm: 1.5; PostCapTopThickness_mm: 3; PostCapPlugDepth_mm: 12; PostCapPlugWall_mm: 2; BraceSide: Leeward *; ProposalLabels: {"BraceAxialEmbedment_mm": "350 *", "BraceConnectionGL_mm": "1775 *", "PostCapPlugDepth_mm": "12 *", "PostCapPlugWall_mm": "2 *", "PostCapTopThickness_mm": "3 *", "PostEmbedment_mm": "350 *", "PostSteelTopGL_mm": "2397 *", "PostTopGL_mm": "2400 *", "RailCentreHeightsAbovePanelBase_mm": "[300, 725, 1150, 1575, 2000] *", "RailCentreHeights_mm": "[350, 775, 1200, 1625, 2050] *", "RailEndClearance_mm": "287.5 *", "SlatCutLength_mm": "2294 *", "SlatEndTrimEachSide_mm": "5.4 *", "SlatInsideBendRadius_mm": "1.879898987322333 *", "SlatOverlap_mm": "3.3 *", "SlatPitch_mm": "62.5 *", "SlatTipRadius_mm": "1.5 *", "VerticalChain_mm": "[287.5, 25, 400, 25, 400, 25, 400, 25, 400, 25, 287.5] *", "WireDiameter_mm": "2 *", "WireDiamondDiagonal_mm": "100 *"}; ReviewScope: PROPOSED - NOT FOR FABRICATION
Name
post_cap_0
post_cap_1
post_cap_2
